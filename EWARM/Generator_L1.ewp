# IAR project Generator_L1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L162RE ST STM32L162RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ../Inc; ..\CMSIS\Inc; ..\FreeRTOS\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Inc
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32l162xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group FreeRTOS
    ../FreeRTOS/Src/: cmsis_os.c croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group System
    ../FreeRTOS/Src/: portasm.s
    ../CMSIS/Src/: startup_stm32l162xe.s
  group User
    ../Src/: Generator.c main.c MCO.c stm32l1xx_it.c System_HSE_init.c
